options:
  parameters:
    generate_options: no_gui
    id: wav
    output_language: python
    title: Play wav
  states: {}

blocks:
- name: if_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '10240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: bandwidth
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: bandwidth
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: intx
    value: '8000'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: file
    repeat: 'True'
  states: {}
- name: file
  id: parameter
  parameters:
    label: WAV file
    type: str
    value: ''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    type: intx
    value: '462562500'
  states: {}
- name: mod
  id: parameter
  parameters:
    label: Modulation [0=NBFM,1=WBFM]
    type: intx
    value: '0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: bandwidth
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_selector_0, '0']
- [analog_wfm_tx_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
