options:
  parameters:
    generate_options: qt_gui
    id: wav
    output_language: python
    title: Play wav
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Frequency
    start: '100000000'
    step: '500'
    stop: '7285000000'
    value: '462562500'
    widget: slider
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: if_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
    widget: slider
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: rf gain
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
    widget: slider
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '10240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: tx_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Bandwidth
    rangeType: int
    start: '1000'
    step: '1000'
    stop: '1000000'
    value: '8000'
    widget: slider
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: tx_bandwidth
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pipewire
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/steve/Source/radio-anarchy/build/audio.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    bw0: tx_bandwidth
    freq0: center_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,1
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
