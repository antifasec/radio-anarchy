options:
  parameters:
    author: antifasec
    generate_options: no_gui
    id: am_wav
    output_language: python
    title: Transmit wav using amplitude modulation
  states: {}

blocks:
- name: audio_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 18e3
    gain: '2'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: intx
    value: '240000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.8'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: file
    repeat: 'True'
  states: {}
- name: file
  id: parameter
  parameters:
    label: WAV file
    type: str
    value: ''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    type: intx
    value: '462562500'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain (0-48)
    type: intx
    value: '24'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '10'
    taps: audio_taps
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12000'
    decim: '1'
    gain: '1'
    samp_rate: '705600'
    type: fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: gain
    bw0: bandwidth
    freq0: freq
    gain0: gain
    if_gain0: gain
    sample_rate: samp_rate * 10
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
