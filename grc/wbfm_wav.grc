options:
  parameters:
    author: antifasec
    generate_options: no_gui
    id: wbfm_wav
    output_language: python
    title: Play wav
  states: {}

blocks:
- name: quad_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate // 10
    fh: '-1.0'
    max_dev: bandwidth
    quad_rate: samp_rate // 10
    tau: '7.5e-5'
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    label: Bandwidth
    type: intx
    value: '20000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: file
    repeat: 'True'
  states: {}
- name: file
  id: parameter
  parameters:
    label: WAV file
    type: str
    value: ''
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Center frequency
    type: intx
    value: '462562500'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain (0-48)
    type: intx
    value: '24'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: gain
    bw0: bandwidth
    freq0: freq
    gain0: gain
    if_gain0: gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: samp_rate
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_tx_0, '0', osmosdr_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
